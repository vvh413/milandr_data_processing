# Keil uVision project image.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\image.sct
  group Source Group 1
    ./: main.c main.h
    ./lib/: image.c lcd.c
    ./include/: image.h lcd.h
software components: Device:Startup 1.5, Drivers:RST_CLK 1.5, Drivers:USB Library 1.5, Drivers:USB 1.5
